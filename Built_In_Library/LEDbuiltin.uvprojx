# Keil uVision project LEDbuiltin.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32H745ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LEDbuiltin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Source\Include;.\Source\Include_LED
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  group main
    ./Source/: main.c
  group include
    ./Source/Include_LED/: LED.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.0
